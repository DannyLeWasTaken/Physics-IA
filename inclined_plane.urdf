Commit message: Increased plane size

File: inclined_plane.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link planeLink: geometry collision box size=20000 20000 10; visual mesh filename=plane100.obj scale=1 1 1
